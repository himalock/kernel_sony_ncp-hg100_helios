## linux-4.4/drivers/misc/helios-misc/Kconfig
```kconfig
#
# Helios misc control
#

config HELIOS_MISC
	bool "Helios Misc control driver"
	help
	  This enables the Helios Misc driver.
```
